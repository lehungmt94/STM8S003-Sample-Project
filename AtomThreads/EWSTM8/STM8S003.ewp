# IAR project STM8S003.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103; xUSE_FULL_ASSERT; xATOM_STACK_CHECKING; DEBUG
  ICCSTM8.CCIncludePath2: ..\..\STM8S_StdPeriph_Driver\inc; ..\inc; ..\..\Atom_kernel
  ICCSTM8.IccExtraOptions: --diag_suppress Pe940
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8S003.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: lnkstm8s103f3.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: STM8S003; xUSE_FULL_ASSERT
  ILINK.IlinkOutputFile: STM8S003.out
  group Atom Kernal
    ../../Atom_kernel/: atomkernel.c atommutex.c atomport-asm-iar.s atomport.c atomqueue.c atomsem.c atomtimer.c
  group STM8_Drivers
    ../../STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_uart1.c stm8s_wwdg.c
  group User
    ./: lnkstm8s103f3.icf
    ../src/: main.c stm8s_it.c
